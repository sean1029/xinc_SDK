# Keil uVision project Xinc_fds_flash.uvprojx, settings and files
target Xinc_M0_Sdk (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: Xc6xxx_fds_flash
  AfterMake: fromelf --bin --output=.\Output\s.bin !L
  AfterMake: .\Tools\Xincboot_tool .\Output\s.bin .\Output\download.bin
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SBC_ENC_INCLUDED XC6028 BOARD_PCA10040
  c include: ..\..\..\Ble\Hid_ble;..\..\..\Bsp;..\..\..\Bsp\sm;..\..\..\Bsp\startup;..\..\..\Include;..\Include;..\..\..\LIB;..\..\..\external\sbc;..\..\..\components\libraries\fds;..\..\..\modules\xincx\hal;..\..\..\modules\xincx;..\..\..\modules\xincx\mdk;..\..\..\modules\xincx\drivers\include;..\..\..\components\libraries\timer;..\..\..\integration\xincx\legacy;..\..\..\components\libraries\util;..\..\..\integration\xincx;..\..\..\components\libraries\button;..\..\..\components\libraries\bsp;..\..\..\components\boards;..\..\..\components\libraries\scheduler;..\..\..\components\libraries\cli;..\..\..\components\libraries\cli\uart;..\..\..\components\libraries\experimental_section_vars;..\..\..\components\libraries\memobj;..\..\..\external\fprintf;..\..\..\components\libraries\queue;..\..\..\components\libraries\balloc;..\..\..\components\libraries\atomic;..\..\..\components\libraries\ringbuf;..\..\..\components\libraries\log;..\..\..\components\libraries\uart;..\..\..\components\libraries\fifo;..\..\..\Bsp\I2C;..\..\..\components\libraries\log\src;..\..\..\components\libraries\log\;..\..\..\components\libraries\strerror;..\..\..\components\header;..\..\..\components\libraries\atomic_fifo;..\..\..\components\libraries\fstorage;..\config\xc6801;..\..\..\components\driver_ext\AT24Cxx;..\..\..\components\libraries\delay;..\..\..\components\driver_ext\Flash;..\..\..\components\libraries\crc16;..\..\..\components\libraries\mem_manager;..\..\..\components\libraries\pwr_mgmt;..\..\..\components\libraries\mutex;..\..\..\modules\xincx\mdk\startup\M0;..\..\..\modules\xincx\mdk\startup
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Linker\cpu.scat
  group sdk_config
    ../config/xc6801/: sdk_config.h
  group startup
    ../../../modules/xincx/mdk/startup/M0/: startup_xinc_m0.s system_xincM0.c core_cm0.c
  group startup_M4
    ../../../modules/xincx/mdk/startup/M4/: system_xinc_m4.c startup_xinc_m4.s
  group application
    ../app/: main.c app_cli.c es_flash.c
    ../../../components/driver_ext/AT24Cxx/: AT24C02.c
    ../../../components/driver_ext/Flash/: xinc_spi_flash.c
  group Board Definition
    ../../../components/boards/: boards.c
  group Board Support
    ../../../components/libraries/bsp/: bsp.c
  group Xinc_Drivers
    ../../../Bsp/: bsp_retarget.c bsp_systick.c bsp_gpio.c bsp_clk.c
    ../../../modules/xincx/drivers/src/: xincx_gpio.c xincx_i2c.c xincx_rtc.c xincx_pwm.c xincx_saadc.c xincx_spim.c xincx_wdt.c xincx_uart.c xincx_uarte.c xincx_kbs.c xincx_timer.c
    ../../../components/libraries/atomic/: xinc_atomic.c
    ../../../integration/xincx/: xinc_drv_i2c.c xinc_drv_spi.c
    ../../../integration/xincx/legacy/: xinc_drv_uart.c
  group Xinc_Libraries
    ../../../components/libraries/log/src/: xinc_log_default_backends.c
    ../../../components/libraries/util/: app_util_poatform.c app_error_weak.c app_error.c
    ../../../components/libraries/button/: app_button.c
    ../../../components/libraries/timer/: app_timer.c
    ../../../components/libraries/scheduler/: app_scheduler.c
    ../../../components/libraries/uart/: app_uart_fifo.c
    ../../../components/libraries/fifo/: app_fifo.c
    ../../../components/libraries/cli/uart/: xinc_cli_uart.c
    ../../../components/libraries/cli/: cli_utils_cmds.c xinc_cli.c
    ../../../components/libraries/balloc/: xinc_balloc.c
    ../../../components/libraries/experimental_section_vars/: xinc_section_iter.c
    ../../../components/libraries/ringbuf/: xinc_ringbuf.c
    ../../../components/libraries/memobj/: xinc_memobj.c
    ../../../external/fprintf/: xinc_fprintf.c xinc_fprintf_format.c
    ../../../components/libraries/crc16/: crc16.c
    ../../../components/libraries/fds/: fds.c
    ../../../components/libraries/fstorage/: xinc_flash.c xinc_fstorage.c xinc_fstorage_flash.c
    ../../../components/libraries/atomic_fifo/: xinc_atfifo.c
    ../../../modules/xincx/drivers/src/: xincx_dmas.c
    ../../../components/libraries/mem_manager/: mem_manager.c
    ../../../components/libraries/pwr_mgmt/: xinc_pwr_mgmt.c
  group Xinc_Log
    ../../../components/libraries/log/src/: xinc_log_backend_uart.c xinc_log_backend_serial.c xinc_log_str_formatter.c xinc_log_frontend.c
target Xinc_M4_Sdk (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: Xc6xxx_fds_flash
  AfterMake: fromelf --bin --output=.\Output\s.bin !L
  AfterMake: .\Tools\Xincboot_tool .\Output\s.bin .\Output\download.bin
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SBC_ENC_INCLUDED XC6658 BOARD_PCA10060
  c include: ..\..\..\Ble\Hid_ble;..\..\..\Bsp;..\..\..\Bsp\sm;..\..\..\Bsp\startup;..\..\..\Include;..\Include;..\..\..\LIB;..\..\..\external\sbc;..\..\..\components\libraries\fds;..\..\..\modules\xincx\hal;..\..\..\modules\xincx;..\..\..\modules\xincx\mdk;..\..\..\modules\xincx\drivers\include;..\..\..\components\libraries\timer;..\..\..\integration\xincx\legacy;..\..\..\components\libraries\util;..\..\..\integration\xincx;..\..\..\components\libraries\button;..\..\..\components\libraries\bsp;..\..\..\components\boards;..\..\..\components\libraries\scheduler;..\..\..\components\libraries\cli;..\..\..\components\libraries\cli\uart;..\..\..\components\libraries\experimental_section_vars;..\..\..\components\libraries\memobj;..\..\..\external\fprintf;..\..\..\components\libraries\queue;..\..\..\components\libraries\balloc;..\..\..\components\libraries\atomic;..\..\..\components\libraries\ringbuf;..\..\..\components\libraries\log;..\..\..\components\libraries\uart;..\..\..\components\libraries\fifo;..\..\..\Bsp\I2C;..\..\..\components\libraries\log\src;..\..\..\components\libraries\log\;..\..\..\components\libraries\strerror;..\..\..\components\header;..\..\..\components\libraries\atomic_fifo;..\..\..\components\libraries\fstorage;..\config\xc6801;..\..\..\components\driver_ext\AT24Cxx;..\..\..\components\libraries\delay;..\..\..\components\driver_ext\Flash;..\..\..\components\libraries\crc16;..\..\..\components\libraries\mem_manager;..\..\..\components\libraries\pwr_mgmt;..\..\..\components\libraries\mutex;..\..\..\modules\xincx\mdk\startup\M4;..\..\..\modules\xincx\mdk\startup
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Linker\cpuM4.scat
