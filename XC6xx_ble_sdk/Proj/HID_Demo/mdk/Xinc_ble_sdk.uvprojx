# Keil uVision project Xinc_ble_sdk.uvprojx, settings and files
target ble-fullstack (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: Xinc_ble_sdk
  AfterMake: fromelf --bin --output=s.bin !L
  AfterMake: Xincboot_tool s.bin download.bin
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SBC_ENC_INCLUDED NRF52840_XXAA BOARD_PCA10040
  c include: ..\..\..\Ble\Hid_ble;..\..\..\Bsp;..\..\..\Bsp\sm;..\..\..\Bsp\startup;..\..\..\Include;..\Include;..\..\..\LIB;..\..\..\external\sbc;..\..\..\Bsp\fds;..\..\..\modules\nrfx\hal;..\..\..\modules\nrfx;..\..\..\modules\nrfx\mdk;..\..\..\modules\nrfx\drivers\include;..\..\..\components\libraries\timer;..\..\..\integration\nrfx\legacy;..\..\..\components\libraries\util;..\..\..\integration\nrfx;..\..\..\components\libraries\button;..\..\..\components\libraries\bsp;..\..\..\components\boards;..\..\..\components\libraries\scheduler;..\..\..\components\libraries\cli;..\..\..\components\libraries\cli\uart;..\..\..\components\libraries\experimental_section_vars;..\..\..\components\libraries\memobj;..\..\..\external\fprintf;..\..\..\components\libraries\queue;..\..\..\components\libraries\balloc;..\..\..\components\libraries\atomic;..\..\..\components\libraries\ringbuf;..\..\..\components\libraries\log;..\..\..\components\libraries\uart;..\..\..\components\libraries\fifo;..\..\..\Bsp\I2C
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\cpu.scat
  group startup
    ../../../Bsp/startup/: core_cm0.c startup_xinc.s system_xinc.c
  group application
    ../app/: battery_service_server.c device_information_service_server.c hog_keyboard_demo.c main.c hids_device.c gatt_client.c voice_ringbuf.c FF10_service_server.c xc_kbs_event.c hids_device_skyworth.c skyworth_RC_demo.c app_cli.c
    ../../../Bsp/: ble_idle.c
  group ble
    ../../../Bsp/: rf_driver.c
    ../../../Ble/: patch.c
    ../../../LIB/: Xinc_ble_sdk_lowpowerv1.3.lib Xinc_ble_sdk_md.lib
  group bsp
    ../../../Bsp/I2C/: AT24C02.c bsp_i2c_master.c
    ../../../Bsp/: bsp_retarget.c bsp_systick.c bsp_gpio.c bsp_pwm.c bsp_timer.c bsp_spi_flash.c test_spi0_flash.c bsp_spi_master.c bsp_uart.c bsp_clk.c
  group sbc
    ../../../external/sbc/: sbc.c sbc_primitives.c sbc_primitives_armv6.c sbc_primitives_iwmmxt.c sbc_primitives_mmx.c sbc_primitives_neon.c
  group fds
    ../../../Bsp/fds/: xinc_fstorage_flash.c xinc_fstorage.c cfc_flash.c nrf_atomic.c app_util_poatform.c fds.c nrf_atfifo.c nrf_strerror.c
  group button
    ../../../components/libraries/button/: app_button.c
    ../../../modules/nrfx/drivers/src/: nrfx_gpiote.c
    ../../../components/libraries/gpiote/: app_gpiote.c
    ../../../components/libraries/util/: app_error.c app_error_weak.c
    ../../../components/libraries/bsp/: bsp.c
    ../../../components/boards/: boards.c
  group timer
    ../../../components/libraries/timer/: app_timer.c
    ../../../components/libraries/scheduler/: app_scheduler.c app_scheduler_serconn.c
  group uart
    ../../../components/libraries/uart/: app_uart.c app_uart_fifo.c
    ../../../components/libraries/fifo/: app_fifo.c
  group cli
    ../../../components/libraries/cli/: cli_utils_cmds.c nrf_cli.c
    ../../../components/libraries/cli/uart/: nrf_cli_uart.c nrf_drv_uart.c
    ../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../components/libraries/queue/: nrf_queue.c
    ../../../components/libraries/balloc/: nrf_balloc.c
    ../../../components/libraries/memobj/: nrf_memobj.c
    ../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../modules/nrfx/drivers/src/: nrfx_uart.c
  group spi
    ../../../modules/nrfx/drivers/src/: nrfx_spim.c
    ../../../integration/nrfx/: xinc_drv_spi.c
  group i2c
    ../../../modules/nrfx/drivers/src/: xincx_i2c.c
    ../../../integration/nrfx/: xinc_drv_i2c.c
target ble_fullstack_mklib (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: Xincble (library)
  AfterMake: fromelf -c -s -o ../1.txt !L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\bsp\startup;..\bsp;..\ble
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\bsp\startup\cpu.scat
