# Keil uVision project Xinc_ble_sdk.uvprojx, settings and files
target ble-fullstack (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: Xinc_ble_sdk
  AfterMake: fromelf --bin --output=s.bin !L
  AfterMake: Xincboot_tool s.bin download.bin
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SBC_ENC_INCLUDED XINC6206_XXAA BOARD_PCA10040
  c include: ..\..\..\Ble\Hid_ble;..\..\..\Bsp;..\..\..\Bsp\sm;..\..\..\Bsp\startup;..\..\..\Include;..\Include;..\..\..\LIB;..\..\..\external\sbc;..\..\..\components\libraries\fds;..\..\..\modules\xincx\hal;..\..\..\modules\xincx;..\..\..\modules\xincx\mdk;..\..\..\modules\xincx\drivers\include;..\..\..\components\libraries\timer;..\..\..\integration\xincx\legacy;..\..\..\components\libraries\util;..\..\..\integration\xincx;..\..\..\components\libraries\button;..\..\..\components\libraries\bsp;..\..\..\components\boards;..\..\..\components\libraries\scheduler;..\..\..\components\libraries\cli;..\..\..\components\libraries\cli\uart;..\..\..\components\libraries\experimental_section_vars;..\..\..\components\libraries\memobj;..\..\..\external\fprintf;..\..\..\components\libraries\queue;..\..\..\components\libraries\balloc;..\..\..\components\libraries\atomic;..\..\..\components\libraries\ringbuf;..\..\..\components\libraries\log;..\..\..\components\libraries\uart;..\..\..\components\libraries\fifo;..\..\..\Bsp\I2C;..\..\..\components\libraries\log\src;..\..\..\components\libraries\log\;..\..\..\components\libraries\strerror;..\..\..\components\header;..\..\..\components\libraries\atomic_fifo;..\..\..\components\libraries\fstorage;..\config\xc6801;..\..\..\components\driver_ext\AT24Cxx
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\cpu.scat
  group startup
    ../../../Bsp/startup/: core_cm0.c startup_xinc.s system_xinc.c
    ./: nrf_sdkconfig.h
    ../config/xc6801/: sdk_config.h
  group application
    ../app/: battery_service_server.c device_information_service_server.c hog_keyboard_demo.c main.c hids_device.c gatt_client.c voice_ringbuf.c FF10_service_server.c xc_kbs_event.c hids_device_skyworth.c skyworth_RC_demo.c app_cli.c app_test.c
    ../../../Bsp/: ble_idle.c
  group ble
    ../../../Bsp/: rf_driver.c
    ../../../Ble/: patch.c
    ../../../LIB/: Xinc_ble_sdk_lowpowerv1.3.lib Xinc_ble_sdk_md.lib
  group bsp
    ../../../Bsp/: bsp_retarget.c bsp_systick.c bsp_gpio.c bsp_pwm.c bsp_timer.c bsp_spi_flash.c test_spi0_flash.c bsp_spi_master.c bsp_uart.c bsp_clk.c
    ../../../Bsp/I2C/: bsp_i2c_master.c
  group sbc
    ../../../external/sbc/: sbc.c sbc_primitives.c sbc_primitives_armv6.c sbc_primitives_iwmmxt.c sbc_primitives_mmx.c sbc_primitives_neon.c
  group fds
    ../../../components/libraries/util/: app_util_poatform.c
    ../../../components/libraries/atomic_fifo/: xinc_atfifo.c
    ../../../components/libraries/atomic/: xinc_atomic.c
    ../../../components/libraries/fstorage/: xinc_fstorage.c xinc_fstorage_flash.c xinc_flash.c
    ../../../components/libraries/fds/: fds.c
  group button
    ../../../components/libraries/button/: app_button.c
    ../../../modules/xincx/drivers/src/: xincx_gpio.c
    ../../../components/libraries/util/: app_error.c app_error_weak.c
    ../../../components/libraries/bsp/: bsp.c
    ../../../components/boards/: boards.c
  group app_timer
    ../../../components/libraries/timer/: app_timer.c
    ../../../components/libraries/scheduler/: app_scheduler.c
  group uart
    ../../../components/libraries/uart/: app_uart.c app_uart_fifo.c
    ../../../modules/xincx/drivers/src/: xincx_uart.c
    ../../../components/libraries/fifo/: app_fifo.c
  group cli
    ../../../components/libraries/cli/: cli_utils_cmds.c xinc_cli.c
    ../../../components/libraries/cli/uart/: xinc_cli_uart.c xinc_drv_uart.c
    ../../../external/fprintf/: xinc_fprintf.c xinc_fprintf_format.c
    ../../../components/libraries/queue/: xinc_queue.c
    ../../../components/libraries/balloc/: xinc_balloc.c
    ../../../components/libraries/memobj/: xinc_memobj.c
    ../../../components/libraries/ringbuf/: xinc_ringbuf.c
  group spi
    ../../../modules/xincx/drivers/src/: xincx_spim.c
    ../../../integration/xincx/: xinc_drv_spi.c
  group i2c
    ../../../modules/xincx/drivers/src/: xincx_i2c.c
    ../../../components/libraries/strerror/: xinc_strerror.c
    ../../../integration/xincx/: xinc_drv_i2c.c
    ../../../components/driver_ext/AT24Cxx/: AT24C02.c
  group log
    ../../../components/libraries/log/src/: xinc_log_backend_uart.c xinc_log_default_backends.c xinc_log_frontend.c xinc_log_str_formatter.c xinc_log_backend_serial.c
  group adc
    ../../../modules/xincx/drivers/src/: xincx_saadc.c
  group rtc
    ../../../modules/xincx/drivers/src/: xincx_rtc.c
  group timer
    ../../../modules/xincx/drivers/src/: xincx_timer.c
  group pwm
    ../../../modules/xincx/drivers/src/: xincx_pwm.c
  group wdt
    ../../../modules/xincx/drivers/src/: xincx_wdt.c
target ble_fullstack_mklib (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: as above
  output: Xincble (library)
  AfterMake: fromelf -c -s -o ../1.txt !L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\bsp\startup;..\bsp;..\ble
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\bsp\startup\cpu.scat
