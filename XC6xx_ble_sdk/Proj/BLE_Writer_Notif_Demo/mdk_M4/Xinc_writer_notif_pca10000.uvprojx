# Keil uVision project Xinc_writer_notif_pca10000.uvprojx, settings and files
target Xinc_M4_Sdk (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: Xc6xxx_ble_wr_ntf
  AfterMake: fromelf --bin --output=.\Output\s.bin !L
  AfterMake: .\tools\Xincboot_tool .\Output\s.bin .\Output\download.bin
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SBC_ENC_INCLUDED XC6651 BOARD_PCA10060 JAL_BASE_ADDR=0x40026000 HAB_BASE_ADDR=0x40028000 JAL_LE_BASE_ADDR=0x4002A000 JAL_LE_TX_ACL_BASE_ADDR=0x40026200 JAL_LE_RX_ACL_BASE_ADDR=0x40026400 HW_DATA32 __BYTE_ORDER=__LITTLE_ENDIAN __USE_INLINES__ BUILD_TYPE=GENERIC_BUILD PRH_BS_CFG_TABASCO_VERSION=PRH_BS_HW_TABASCO_VERSION_T2_0_0 HW_RADIO=HWradio_ORCA_ORC2110 BLUETOOTH_MODE_LE_ONLY
  c include: ..\config;..\..\..\modules\xincx\mdk\startup;..\..\..\modules\xincx\mdk\startup\M4;..\..\..\ble_rom\btstack;..\..\..\ble_rom\btstack\ble_stack_inc;..\..\..\ble_rom\btstack\src;..\..\..\ble_rom\btstack\src\classic;..\..\..\ble_rom\btstack\src\ble;..\..\..\ble_rom\btstack\src\ble\gatt-service;..\..\..\ble_rom\firmware\core\sys\include;..\..\..\ble_rom\firmware\hal\xinc\sys\include;..\..\..\ble_rom\firmware\core\le\include;..\..\..\Include;..\..\..\components\ble\M4\ROM;..\..\..\modules\xincx\mdk;..\..\..\Bsp;..\..\..\ble_rom;..\..\..\external\sbc;..\..\..\components\libraries\fds;..\..\..\modules\xincx;..\..\..\modules\xincx\hal;..\..\..\modules\xincx\mdk;..\..\..\modules\xincx\drivers\include;..\..\..\components\libraries\timer;..\..\..\integration\xincx\legacy;..\..\..\components\libraries\util;..\..\..\integration\xincx;..\..\..\components\boards;..\..\..\components\libraries\button;..\..\..\components\libraries\bsp;..\..\..\components\libraries\scheduler;..\..\..\components\libraries\cli;..\..\..\components\libraries\cli\uart;..\..\..\components\libraries\experimental_section_vars;..\..\..\components\libraries\memobj;..\..\..\external\fprintf;..\..\..\components\libraries\queue;..\..\..\components\libraries\balloc;..\..\..\components\libraries\atomic;..\..\..\components\libraries\ringbuf;..\..\..\components\libraries\log;..\..\..\components\libraries\uart;..\..\..\components\libraries\fifo;..\..\..\components\libraries\log\src;..\..\..\components\libraries\log\;..\..\..\components\libraries\strerror;..\..\..\components\header;..\..\..\components\libraries\atomic_fifo;..\..\..\components\libraries\fstorage;..\..\..\components\libraries\delay;..\..\..\components\libraries\mem_manager;..\..\..\components\libraries\pwr_mgmt;..\..\..\components\libraries\mutex;..\profile
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Linker\cpuM4.scat
  link misc: --entry Reset_Handler
  group sdk_config
    ../config/: sdk_config.h
  group startup_M4
    ../../../modules/xincx/mdk/startup/M4/: startup_xinc_m4.s system_xinc_m4.c
  group application_M4
    ../app/M4/: main.c ble_idle.c battery_service_server.c hog_mouse_demo.c master.c device_information_service_server.c
    ../profile/: profile.c
  group M4_btstack
    ../../../components/ble/M4/ROM/: rom.lib rom_variable.c
    ../../../ble_rom/: ble.c patch.c
    ../../../ble_rom/firmware/hal/hw/radio/orca_orc2110/: hw_radio.c rf_driver.c
  group BleServices
    ../app/M4/: hids_device.c
  group Board Definition
    ../../../components/boards/: boards.c
  group Board Support
    ../../../components/libraries/bsp/: bsp.c
  group Xinc_Drivers
    ../../../Bsp/: bsp_retarget.c bsp_systick.c bsp_gpio.c bsp_clk.c bsp_timer.c
    ../../../modules/xincx/drivers/src/: xincx_gpio.c xincx_i2c.c xincx_rtc.c xincx_kbs.c xincx_spim.c xincx_dmas.c xincx_timer.c
    ../../../components/libraries/atomic/: xinc_atomic.c
    ../../../integration/xincx/: xinc_drv_i2c.c xinc_drv_spi.c
  group Xinc_Libraries
    ../../../components/libraries/log/src/: xinc_log_default_backends.c
    ../../../components/libraries/util/: app_util_poatform.c app_error_weak.c app_error.c
    ../../../components/libraries/button/: app_button.c
    ../../../components/libraries/timer/: app_timer.c
    ../../../components/libraries/scheduler/: app_scheduler.c
    ../../../components/libraries/mem_manager/: mem_manager.c
    ../../../components/libraries/pwr_mgmt/: xinc_pwr_mgmt.c
    ../../../components/libraries/experimental_section_vars/: xinc_section_iter.c
  group Xinc_Log
    ../../../components/libraries/log/src/: xinc_log_backend_uart.c xinc_log_backend_serial.c xinc_log_str_formatter.c xinc_log_frontend.c
