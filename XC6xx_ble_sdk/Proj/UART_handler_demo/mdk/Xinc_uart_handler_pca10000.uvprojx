# Keil uVision project Xinc_uart_handler_pca10000.uvprojx, settings and files
target ble-fullstack (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: Xc6206xx_rtc
  AfterMake: fromelf --bin --output=s.bin !L
  AfterMake: Xincboot_tool s.bin download.bin
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SBC_ENC_INCLUDED XC6028 BOARD_PCA10040
  c include: ..\..\..\Ble\Hid_ble;..\..\..\Bsp;..\..\..\Bsp\sm;..\..\..\Bsp\startup;..\..\..\Include;..\Include;..\..\..\LIB;..\..\..\external\sbc;..\..\..\components\libraries\fds;..\..\..\modules\xincx\hal;..\..\..\modules\xincx;..\..\..\modules\xincx\mdk;..\..\..\modules\xincx\drivers\include;..\..\..\components\libraries\timer;..\..\..\integration\xincx\legacy;..\..\..\components\libraries\util;..\..\..\integration\xincx;..\..\..\components\libraries\button;..\..\..\components\libraries\bsp;..\..\..\components\boards;..\..\..\components\libraries\scheduler;..\..\..\components\libraries\cli;..\..\..\components\libraries\cli\uart;..\..\..\components\libraries\experimental_section_vars;..\..\..\components\libraries\memobj;..\..\..\external\fprintf;..\..\..\components\libraries\queue;..\..\..\components\libraries\balloc;..\..\..\components\libraries\atomic;..\..\..\components\libraries\ringbuf;..\..\..\components\libraries\log;..\..\..\components\libraries\uart;..\..\..\components\libraries\fifo;..\..\..\Bsp\I2C;..\..\..\components\libraries\log\src;..\..\..\components\libraries\log\;..\..\..\components\libraries\strerror;..\..\..\components\header;..\..\..\components\libraries\atomic_fifo;..\..\..\components\libraries\fstorage;..\config\xc6801;..\..\..\components\driver_ext\AT24Cxx;..\..\..\components\libraries\delay;..\..\..\components\driver_ext\Flash;..\..\..\Bsp\startup\m0
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\Bsp\startup\m0\cpu_m0.scat
  group startup_m0
    ./: nrf_sdkconfig.h
    ../config/xc6801/: sdk_config.h
    ../../../Bsp/startup/m0/: core_cm0.c startup_xinc_m0.s system_xinc_m0.c
  group startup_m4
    ../../../Bsp/startup/m4/: cmsis_armcc.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_xinc_m4.s system_xinc_m4.c
  group application
    ../app/: main.c xc_kbs_event.c
    ../../../components/driver_ext/AT24Cxx/: AT24C02.c
    ../../../components/driver_ext/Flash/: xinc_spi_flash.c
  group ble
    ../../../Bsp/: ble_idle.c rf_driver.c
    ../app/: gatt_client.c hids_device_skyworth.c device_information_service_server.c battery_service_server.c skyworth_RC_demo.c FF10_service_server.c voice_ringbuf.c
    ../../../Ble/: patch.c
    ../../../LIB/: Xinc_ble_sdk_lowpowerv1.3.lib Xinc_ble_sdk_md.lib
  group Board Definition
    ../../../components/boards/: boards.c
  group Board Support
    ../../../components/libraries/bsp/: bsp.c
  group Xinc_Drivers
    ../../../Bsp/: bsp_retarget.c bsp_systick.c bsp_gpio.c bsp_clk.c
    ../../../modules/xincx/drivers/src/: xincx_gpio.c xincx_i2c.c xincx_rtc.c xincx_pwm.c xincx_saadc.c xincx_spim.c xincx_wdt.c xincx_uart.c xincx_uarte.c xincx_dmas.c xincx_kbs.c
    ../../../components/libraries/atomic/: xinc_atomic.c
    ../../../integration/xincx/: xinc_drv_i2c.c xinc_drv_spi.c
    ../../../integration/xincx/legacy/: xinc_drv_uart.c
  group Xinc_Libraries
    ../../../components/libraries/log/src/: xinc_log_default_backends.c
    ../../../components/libraries/util/: app_util_poatform.c app_error_weak.c app_error.c
    ../../../components/libraries/button/: app_button.c
    ../../../components/libraries/timer/: app_timer.c
    ../../../components/libraries/scheduler/: app_scheduler.c
    ../../../components/libraries/uart/: app_uart_fifo.c
    ../../../components/libraries/fifo/: app_fifo.c
  group Xinc_Log
    ../../../components/libraries/log/src/: xinc_log_backend_uart.c xinc_log_backend_serial.c xinc_log_str_formatter.c xinc_log_frontend.c
target ble_fullstack_mklib (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: as above
  output: Xincble (library)
  AfterMake: fromelf -c -s -o ../1.txt !L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\bsp\startup;..\bsp;..\ble
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\bsp\startup\cpu.scat
target ble-fullstack_M4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: Xc6206xx_rtc
  AfterMake: fromelf --bin --output=s.bin !L
  AfterMake: Xincboot_tool s.bin download.bin
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SBC_ENC_INCLUDED XC6658 BOARD_PCA10040
  c include: ..\..\..\Ble\Hid_ble;..\..\..\Bsp;..\..\..\Bsp\sm;..\..\..\Bsp\startup;..\..\..\Include;..\Include;..\..\..\LIB;..\..\..\external\sbc;..\..\..\components\libraries\fds;..\..\..\modules\xincx\hal;..\..\..\modules\xincx;..\..\..\modules\xincx\mdk;..\..\..\modules\xincx\drivers\include;..\..\..\components\libraries\timer;..\..\..\integration\xincx\legacy;..\..\..\components\libraries\util;..\..\..\integration\xincx;..\..\..\components\libraries\button;..\..\..\components\libraries\bsp;..\..\..\components\boards;..\..\..\components\libraries\scheduler;..\..\..\components\libraries\cli;..\..\..\components\libraries\cli\uart;..\..\..\components\libraries\experimental_section_vars;..\..\..\components\libraries\memobj;..\..\..\external\fprintf;..\..\..\components\libraries\queue;..\..\..\components\libraries\balloc;..\..\..\components\libraries\atomic;..\..\..\components\libraries\ringbuf;..\..\..\components\libraries\log;..\..\..\components\libraries\uart;..\..\..\components\libraries\fifo;..\..\..\Bsp\I2C;..\..\..\components\libraries\log\src;..\..\..\components\libraries\log\;..\..\..\components\libraries\strerror;..\..\..\components\header;..\..\..\components\libraries\atomic_fifo;..\..\..\components\libraries\fstorage;..\config\xc6801;..\..\..\components\driver_ext\AT24Cxx;..\..\..\components\libraries\delay;..\..\..\components\driver_ext\Flash;..\..\..\Bsp\startup\m4
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\Bsp\startup\m4\cpu_m4.scat
