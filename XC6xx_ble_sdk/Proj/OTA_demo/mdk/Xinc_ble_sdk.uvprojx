# Keil uVision project Xinc_ble_sdk.uvprojx, settings and files
target ble-sdk (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: Xinc_ble_sdk
  AfterMake: fromelf --bin --output=s.bin !L
  AfterMake: Xincboot_tool s.bin download.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\app\demo;..\..\..\Ble\OTA_ble;..\..\..\Bsp;..\..\..\Bsp\startup;..\..\..\Include;..\..\..\Ble\btstack;..\..\..\Ble\btstack\src;..\..\..\Ble\btstack\src\classic;..\..\..\Ble\btstack\src\ble;..\..\..\Ble\btstack\src\ble\gatt-service;..\app
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\Bsp\startup\cpu.scat
  group startup
    ../../../Bsp/startup/: core_cm0.c startup_xinc.s
    ../app/: system_init.c
  group application
    ../app/: main.c gatt_client.c xinchip_ota.c
  group ble
    ../../../Bsp/: rf_driver.c
    ../../../Ble/: patch.c
    ../../../LIB/: Xinc_ble_sdk_lowpowerv1.3.lib
  group bsp
    ../../../Bsp/: bsp_systick.c bsp_uart.c bsp_gpio.c bsp_spi_master.c bsp_wdog.c
  group Include
    ../../../Include/: Platform.h
