# Keil uVision project Xinc_ble_sdk.uvprojx, settings and files
target ble-fullstack (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: Xinc_ble_sdk
  AfterMake: fromelf --bin --output=s.bin !L
  AfterMake: Xincboot_tool s.bin download.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\Ble;..\..\..\Bsp;..\..\..\Bsp\sm;..\..\..\Bsp\startup;..\..\..\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\cpu.scat
  group startup
    ../../../Bsp/startup/: core_cm0.c system_xinc.c startup_xinc.s
  group application
    ../app/: main.c
  group ble
    ../../../Bsp/: rf_driver.c
    ../../../Ble/: patch.c
    ../../../LIB/: Xinc_ble_sdk_nonlowpowerv1.3.lib
  group bsp
    ../../../Bsp/sm/: bsp_timer.c
    ../../../Bsp/: bsp_retarget.c bsp_systick.c bsp_gpio.c
target ble_fullstack_mklib (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: as above
  output: Xincble (library)
  AfterMake: fromelf -c -s -o ../1.txt !L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\bsp\startup;..\bsp;..\ble
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\bsp\startup\cpu.scat
